# Keil uVision project stockCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: stockCar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: stockCar.c Font_Header.h
